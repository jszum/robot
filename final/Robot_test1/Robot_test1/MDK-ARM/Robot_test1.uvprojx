# Keil uVision project Robot_test1.uvprojx, settings and files
target Robot_test1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F072RB STMicroelectronics
  pack: Keil.STM32F0xx_DFP.2.0.0
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M0")
  output: Robot_test1
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F072xB
  c include: ../../../Inc;  ../../../Drivers/STM32F0xx_HAL_Driver/Inc;  ../../../Drivers/STM32F0xx_HAL_Driver/Inc/Legacy;  ../../../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM0;  ../../../Drivers/CMSIS/Device/ST/STM32F0xx/Include;  ../../../Middlewares/Third_Party/FreeRTOS/Source/include;  ../../../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;  ../../../Drivers/CMSIS/Include
  asm include: ..\..\..\\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group Application/MDK-ARM
    ./: startup_stm32f072xb.s
  group Drivers/STM32F0xx_HAL_Driver
    ../../../Drivers/STM32F0xx_HAL_Driver/Src/: stm32f0xx_hal_flash_ex.c stm32f0xx_hal_tim.c stm32f0xx_hal_dma.c stm32f0xx_hal_tim_ex.c stm32f0xx_hal_i2c_ex.c stm32f0xx_hal_uart_ex.c stm32f0xx_hal_pwr.c stm32f0xx_hal_i2c.c stm32f0xx_hal_rcc_ex.c stm32f0xx_hal_pwr_ex.c stm32f0xx_hal.c stm32f0xx_hal_gpio.c stm32f0xx_hal_flash.c stm32f0xx_hal_uart.c stm32f0xx_hal_rcc.c stm32f0xx_hal_cortex.c
  group Middlewares/FreeRTOS
    ../../../Middlewares/Third_Party/FreeRTOS/Source/: tasks.c queue.c timers.c event_groups.c list.c croutine.c
    ../../../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../../../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM0/: port.c
    ../../../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
  group Drivers/CMSIS
    ../../..//Src/: system_stm32f0xx.c
  group Application/User
    ../../../Src/: stm32f0xx_hal_timebase_TIM.c stm32f0xx_it.c freertos.c stm32f0xx_hal_msp.c main.c robot_map.c
software components: CMSIS:CORE 4.3.0
